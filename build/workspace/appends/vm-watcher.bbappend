inherit externalsrc
EXTERNALSRC = "/home/jinminu/projects/VmWatcher/vmwatcher"
EXTERNALSRC_BUILD = "/home/jinminu/projects/VmWatcher/vmwatcher"
